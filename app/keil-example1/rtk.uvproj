# Keil uVision project rtk.uvproj, settings and files
target Target 1 (ARM-ADS)
  device: STM32F103ZE STMicroelectronics
  cpu: IRAM(0x20000000-0x2000FFFF) IROM(0x8000000-0x807FFFF) CLOCK(8000000) CPUTYPE("Cortex-M3")
  output: rtk
  c flags: Optim=1
  c define: STM32F10X_HD,USE_STDPERIPH_DRIVER
  c include: ..\..\bsp\stm32f10x;..\..\bsp\stm32f10x\Libraries\CMSIS\CM3\CoreSupport;..\..\bsp\stm32f10x\Libraries\STM32F10x_StdPeriph_Driver\inc;..\..\bsp\stm32f10x\Libraries\CMSIS\CM3\DeviceSupport\ST\STM32F10x;..\..\include
  memory RVCT4: ROM 0x8000000 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x10000
  scatter file: .\stm32_rom.sct
  group rtk
    ../../kernel/: kernel.c
    ../../arch/arm/: armv7m_context.c armv7m_context_rvds.S
    ../../libs/: kprintf.c
  group bsp
    ../../bsp/stm32f10x/: bsp.c startup_stm32f10x_rvds_hd.s
  group STM32F10xLIB
    ../../bsp/stm32f10x/Libraries/CMSIS/CM3/CoreSupport/: core_cm3.c
    ../../bsp/stm32f10x/Libraries/CMSIS/CM3/DeviceSupport/ST/STM32F10x/: system_stm32f10x.c
    ../../bsp/stm32f10x/Libraries/STM32F10x_StdPeriph_Driver/src/: misc.c stm32f10x_adc.c stm32f10x_bkp.c stm32f10x_can.c stm32f10x_cec.c stm32f10x_crc.c stm32f10x_dac.c stm32f10x_dbgmcu.c stm32f10x_dma.c stm32f10x_exti.c stm32f10x_flash.c stm32f10x_fsmc.c stm32f10x_gpio.c stm32f10x_i2c.c stm32f10x_iwdg.c stm32f10x_pwr.c stm32f10x_rcc.c stm32f10x_rtc.c stm32f10x_sdio.c stm32f10x_spi.c stm32f10x_tim.c stm32f10x_usart.c stm32f10x_wwdg.c
  group app
    ./: main.c serail.c led.c
